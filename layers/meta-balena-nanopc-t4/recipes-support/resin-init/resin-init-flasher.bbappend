# On FriendlyElec NanoPC-T4 we flash the balena.io OS on the emmc
INTERNAL_DEVICE_KERNEL = "mmcblk1"

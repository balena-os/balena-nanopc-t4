include resin-image.inc

RESIN_BOOT_PARTITION_FILES = " \
    idbloader.bin:/ \
    rkbin/trust.img:/trust.img \
    uboot.img:/ \
"
